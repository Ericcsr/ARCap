Commit message: post demo wrap up

File: data_processing/assets/franka_arm/panda_gripper.urdf (robot description, URDF)
Before this commit: robot panda, 11 links, 10 joints
Joints:
- joint panda_grasptarget_hand: origin xyz=0 0.0 0.155 rpy=0 0 0 -> xyz=0 0.0 0.165 rpy=0 0 0
